# IAR project nb-iot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD; _DLIB_FILE_DESCRIPTOR; DEBUG_CLOCK=1; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; Mfrc522; USART2; BMPI2C; ADC; BMP280; LORA; 12864; USART4; CMD; GPRS; IIC; I2C; 24cxx; PCF8563; LOCK; CRC; SHT10; GPIO; GPS; MCP3204; NBIOT; SPI; USART; ..\common\hal\include; ..\common\lib\CMSIS\CM3\CoreSupport; ..\common\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\common\lib\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: nb-iot-lOCK.hex
  ILINK.IlinkOutputFile: led.out
  ILINK.IlinkAdditionalLibs: Debug\Exe\nb-iot.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  ICCARM.CCDefines: NDEBUG; STM32F10X_MD; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\common\hal\include; ..\common\lib\CMSIS\CM3\CoreSupport; ..\common\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\common\lib\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 2
  ILINK.IlinkOutputFile: InfObstacle.out
  group hal
    ADC/: adc.c
    BMP280/: BMP280.c
    CRC/: CRC.c
    ../common/hal/src/: delay.c
    GPIO/: gpio.c
    GPRS/: GPRSLib.c
    GPS/: GPSLib.c
    I2C/: I2C.c
    IIC/: IIC.c
    12864/: lcd12864.c
    LOCK/: lock.c
    Mfrc522/: mfrc522.c
    BMPI2C/: myiic.c
    NBIOT/: NBIOTLib.c
    PCF8563/: PCF8563.c
    SHT10/: sht10.c
    USART4/: UART4.C
    LORA/: UM402Lib.c
    USART/: usart.c
  group lib/CMMIS
    ../common/lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../common/lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group lib/CMMIS/startup
    ../common/lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
  group lib/STM32F10x_StdPeriph_Driver
    ../common/lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_it.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group USER
    ./: main.c
