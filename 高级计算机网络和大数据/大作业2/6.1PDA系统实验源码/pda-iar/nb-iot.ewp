# IAR project nb-iot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD; _DLIB_FILE_DESCRIPTOR; DEBUG_CLOCK=1; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; ADC; USART2; BMP085; Key; 12864; RTC; IIC; UM402; LOCK; CRC16; SHT10; GPIO; Time2; Time3; Time4; MCP3204; NFC; SHT1X; UART; UART2; UART3; UART4; ..\common\hal\include; ..\common\lib\CMSIS\CM3\CoreSupport; ..\common\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\common\lib\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 6.1PDA.hex
  ILINK.IlinkOutputFile: led.out
  ILINK.IlinkAdditionalLibs: Debug\Exe\nb-iot.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  ICCARM.CCDefines: NDEBUG; STM32F10X_MD; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\common\hal\include; ..\common\lib\CMSIS\CM3\CoreSupport; ..\common\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\common\lib\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 2
  ILINK.IlinkOutputFile: InfObstacle.out
  group hal
    ADC/: adc.c
    BMP085/: BMP280.c myiic.c
    ./: CmdLib.c
    CRC16/: CRC16.C
    GPIO/: GPIO.c
    RTC/: I2C.c PCF8563.c
    IIC/: IIC.c
    Key/: Key.c
    12864/: lcd12864.c
    NFC/: mfrc522.c
    SHT1X/: SHT1x.c
    Time2/: Time2.c
    Time3/: Time3.c
    Time4/: Time4.c
    UART2/: UART2.c
    UART3/: UART3.c
    UART4/: UART4.C
    UART/: UARTS.c
  group lib/CMMIS
    ../common/lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../common/lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group lib/CMMIS/startup
    ../common/lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
  group lib/STM32F10x_StdPeriph_Driver
    ../common/lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_it.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ./: main.c stm32f10x_conf.h SysTick.c
